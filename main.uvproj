# Keil uVision project main.uvproj, settings and files
target main (MCS-51)
  device: Core8051 Actel
  cpu: IRAM(0-0xFF) IROM(0-0xFFF) CLOCK(12000000)
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: main.c
  group chip_platform
    ./chip_platform/: platform_interface.c
  group task_scheduling_core
    ./task_scheduling_core/: task_scheduling_core.c
  group device
    ./device/: eeprom.c key.c lcd1602.c led.c uart.c
  group driver
    ./driver/: gpio_i2c_interface.c
